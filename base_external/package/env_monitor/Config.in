## base_external/package/env_monitor/Config.in
```kconfig
config BR2_PACKAGE_ENV_MONITOR
	bool "env_monitor"
	help
	  Includes the environment monitor application in target root filesystem
```
